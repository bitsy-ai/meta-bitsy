PYPI_PACKAGE = "OctoPrint"
LICENSE = "AGPLv3"
inherit pypi setuptools3
