require recipes-core/images/printnanny-mainsail-release-image.bb
require recipes-core/images/include/debug.inc

SWUPDATE_IMAGES_FSTYPES[printnanny-mainsail-debug-image-raspberrypi4-64] = ".ext4.gz"
