require recipes-core/images/printnanny-octoprint-klipper-release-image.bb
require recipes-core/images/include/debug.inc

SWUPDATE_IMAGES_FSTYPES[printnanny-octoprint-klipper-debug-image-raspberrypi4-64] = ".ext4.gz"
