SUMMARY = "Extract attributes docstrings defined in various ways"
HOMEPAGE = "https://github.com/danields761/class-doc"
AUTHOR = "Daniel Daniels <danields761@gmail.com>"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit pypi setuptools3
SRC_URI[sha256sum] = "f5e036ed9b7f6de528affdd9f038851910b342d4c1c1252983a55ff080b530e0"