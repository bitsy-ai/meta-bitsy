
SUMMARY = "comprehensive password hashing framework supporting over 30 schemes"
HOMEPAGE = "https://passlib.readthedocs.io/en/stable/"
AUTHOR = "Eli Collinsi <elic@assurancetechnologies.com>"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c8449c5e10474d113ab787ed2753bafe"

SRC_URI[sha256sum] = "defd50f72b65c5402ab2c573830a6978e5f202ad0d984793c8dde2c4152ebe04"
inherit pypi setuptools3
PYPI_PACKAGE = "passlib"
