SUMMARY = "PrintNanny x OctoPrint event models"
HOMEPAGE = "https://github.com/bitsy-ai/printnanny-asyncapi-schema"
AUTHOR = "Leigh Johnson <leigh@printnanny.ai>"
LICENSE = "AGPLv3"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/GPL-3.0-or-later;md5=1c76c4cc354acaac30ed4d5eefea7245"
SRC_URI[sha256sum] = "fac02a34c230f78d442e7bb4c5d3ec95e4ce0618cc6020a613e1e960d53e6c80"
PYPI_PACKAGE = "printnanny-octoprint-models"

inherit pypi python_setuptools_build_meta