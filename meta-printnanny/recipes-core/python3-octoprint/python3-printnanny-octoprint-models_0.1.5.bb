SUMMARY = "PrintNanny x OctoPrint event models"
HOMEPAGE = "https://github.com/bitsy-ai/printnanny-asyncapi-schema"
AUTHOR = "Leigh Johnson <leigh@printnanny.ai>"
LICENSE = "AGPLv3"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/GPL-3.0-or-later;md5=1c76c4cc354acaac30ed4d5eefea7245"
SRC_URI[sha256sum] = "ed00805c8791638f9ff6287ea7938bd012c6f7f8e9cf3675c2ca1b6e5c363c62"
PYPI_PACKAGE = "printnanny-octoprint-models"

inherit pypi python_setuptools_build_meta