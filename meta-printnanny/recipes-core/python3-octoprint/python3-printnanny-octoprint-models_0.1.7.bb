SUMMARY = "PrintNanny x OctoPrint event models"
HOMEPAGE = "https://github.com/bitsy-ai/printnanny-asyncapi-schema"
AUTHOR = "Leigh Johnson <leigh@printnanny.ai>"
LICENSE = "AGPLv3"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/GPL-3.0-or-later;md5=1c76c4cc354acaac30ed4d5eefea7245"
SRC_URI[sha256sum] = "12dbcc8791a570291d214d6a2843902410dfa3dee3b04e036f0733f6cbcc3179"
PYPI_PACKAGE = "printnanny-octoprint-models"

inherit pypi python_setuptools_build_meta