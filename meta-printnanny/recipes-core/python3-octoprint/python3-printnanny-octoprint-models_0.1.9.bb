SUMMARY = "PrintNanny x OctoPrint event models"
HOMEPAGE = "https://github.com/bitsy-ai/printnanny-asyncapi-schema"
AUTHOR = "Leigh Johnson <leigh@printnanny.ai>"
LICENSE = "AGPLv3"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/GPL-3.0-or-later;md5=1c76c4cc354acaac30ed4d5eefea7245"
SRC_URI[sha256sum] = "ebdccd4c3546b983585f1f9ab1860b87fa8edff0887a5b2c2428eaa72b577dfd"
PYPI_PACKAGE = "printnanny-octoprint-models"

inherit pypi python_setuptools_build_meta