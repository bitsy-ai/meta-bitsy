DEPENDS += "libyaml"
RDEPENDS:${PN} += "libyaml-dev"
INSANE_SKIP:${PN} += "dev-deps"