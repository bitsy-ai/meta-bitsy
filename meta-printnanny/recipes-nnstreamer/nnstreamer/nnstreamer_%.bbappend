DEPENDS += "tensorflow-lite"
