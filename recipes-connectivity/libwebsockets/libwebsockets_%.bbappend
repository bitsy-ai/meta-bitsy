PACKAGECONFIG[ipv6] = "-DLWS_IPV6=OFF,-DLWS_IPV6=ON,"
