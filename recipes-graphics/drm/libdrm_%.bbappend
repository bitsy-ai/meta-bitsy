PACKAGECONFIG = "libkms vc4 install-test-programs"
