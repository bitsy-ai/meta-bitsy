PACKAGECONFIG = "allapps"
