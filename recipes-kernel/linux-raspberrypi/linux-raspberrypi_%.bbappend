FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://module-compress-xz.cfg \
"
